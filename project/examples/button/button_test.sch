v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {button.sym} 0 0 0 0 {name=VBUTTON1}
C {opin.sym} 140 60 2 1 {name=p1 lab=btn_out}
C {ipin.sym} -50 60 0 0 {name=p2 lab=VGND}
